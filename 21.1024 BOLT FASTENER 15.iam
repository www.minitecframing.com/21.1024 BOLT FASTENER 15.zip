# Autodesk Inventor assembly: 21.1024 BOLT FASTENER 15
## iProperties
Created: 2006-12
Part Number: 21.1024 BOLT FASTENER 15
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
